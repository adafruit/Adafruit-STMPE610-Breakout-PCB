# Repository adafruit/Adafruit-STMPE610-Breakout-PCB

File README.md:

# Adafruit Resistive Touch Screen Controller STMPE610 Breakout PCB
<a href="http://www.adafruit.com/products/1571"><br/>
Click here to purchase one from the Adafruit shop</a>

This breakout board features the STMPE610, which has both I2C and SPI interfaces available. There is also an interrupt pin that you can use to indicate when a touch has been detected to your microcontroller or microcomputer. We wrapped up the chip with a 3V voltage regulator and level shifting so it's safe to use with 3V or 5V logic. Its a nicely designed chip, and has very stable precise readings. We found its also a lot faster than trying to do all the readings on an Arduino.

PCB files for the STMPE610 Breakout, the format is EagleCAD schematic and board layout
- https://www.adafruit.com/product/1571

### License

Adafruit invests time and resources providing this open source design, please support Adafruit and open-source hardware by purchasing products from [Adafruit](https://www.adafruit.com)!

All text above must be included in any redistribution

Designed by Limor Fried/Ladyada for Adafruit Industries.
Creative Commons Attribution/Share-Alike, all text above must be included in any redistribution. 
See license.txt for additional information.

## EAGLE design Adafruit STMPE610.brd

Parts:
C1: 0.1uF; 0805-NO
C2: 10uF; 0805-NO
D1: 1N4148; SOD-323F
FID1, FID2, FID3: FIDUCIAL""; FIDUCIAL_1MM
JP1: HEADER-1X11; 1X11_ROUND
JP4, JP5: HEADER-1X2ROUND; 1X02_ROUND
Q1, Q2: BSS138; SOT23
R1, R2, R3, R4, R5, R6: 10K; 0805-NO
U1: STMPE610; QFN16_3MM
U2: MIC5225-3.3; SOT23-5
U$4, U$5: MOUNTINGHOLE2.5; MOUNTINGHOLE_2.5_PLATED
U$7: FPC_4PIN_12969; FPC_CONN_1MM_DUAL_4P

Connections:
+3V3: C1.1, JP1.3, Q1.1 (G), Q2.1 (G), R1.2, R4.1, R5.2, U1.P$6 (VCC), U1.P$14 (VIO), U2.5 (OUT)
+5V: C2.1, JP1.1, R2.2, R3.1, U2.1 (IN), U2.3 (EN)
A0: JP1.8, R6.2, U1.P$3 (A0/MISO)
GND: C1.2, C2.2, JP1.2, R6.1, U1.P$10 (GND), U2.2 (GND)
GPIO2: JP1.5, U1.P$11 (IN2/GPIO2)
GPIO3: JP1.4, U1.P$12 (IN3/GPIO3)
INT: JP1.9, U1.P$2 (INT)
MODE: JP1.6, U1.P$9 (MODE)
MOSI_3V: D1.A, R5.1, U1.P$7 (MOSI)
MOSI_5V: D1.C, JP1.7
SCL_3V: Q1.2 (S), R1.1, U1.P$4 (SCLK)
SCL_5V: JP1.10, Q1.3 (D), R2.1
SDA_3V: Q2.2 (S), R4.2, U1.P$5 (SDA/CS)
SDA_5V: JP1.11, Q2.3 (D), R3.2
X+: JP4.1, U1.P$13 (X+), U$7.1 (4)
X-: JP5.2, U1.P$16 (X-), U$7.3 (2)
Y+: JP4.2, U1.P$15 (Y+), U$7.2 (3)
Y-: JP5.1, U1.P$1 (Y-), U$7.4 (1)

Board: 2 copper layers, 27.9 x 21.0 mm, 24 parts (1 on the bottom side), 18 nets.

Other parts of the board:
U$6: ADAFRUIT_TEXT_20MM
U$8: ADAFRUIT_3.5MM

## Commit log

2015-05-19 init

Notices in the files:
parts and their libraries:
microbuilder: This work is placed in the public domain, and may be freely used for commercial and non-commercial work with the following conditions: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
